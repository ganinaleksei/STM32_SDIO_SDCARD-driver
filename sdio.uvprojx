# Keil uVision project sdio.uvprojx, settings and files
target sdio (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: sdio +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: .\driver\inc;.\STM32F10x_StdPeriph_Driver\inc;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/src/: main.c stm32f10x_it.c usart1.c
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_dma.c
  group driver
    ./driver/src/: stm32_eval_sdio_sd.c
  group ::Device
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
